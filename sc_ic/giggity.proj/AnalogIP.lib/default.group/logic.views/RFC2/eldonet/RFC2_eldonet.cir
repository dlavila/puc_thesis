* Component: $AnalogIP/default.group/logic.views/RFC2  Viewpoint: eldonet
.INCLUDE $AnalogIP/default.group/logic.views/RFC2/eldonet/RFC2_eldonet.spi
.INCLUDE $MGC_DESIGN_KIT/models/ELDO/include_all
.PROBE VX

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27

.OPTION PROBOP2
.OPTION PROBOPX
.OP
.AC dec 10 1 10gig
