* Component: $AnalogIP/default.group/logic.views/FC_OTA  Viewpoint: eldonet
.INCLUDE $AnalogIP/default.group/logic.views/FC_OTA/eldonet/FC_OTA_eldonet.spi
.INCLUDE $MGC_DESIGN_KIT/models/ELDO/include_all
.PROBE VX

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27

.AC dec 10 1 10gig
