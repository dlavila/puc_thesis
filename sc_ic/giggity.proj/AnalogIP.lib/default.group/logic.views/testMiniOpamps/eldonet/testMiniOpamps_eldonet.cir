* Component: $AnalogIP/default.group/logic.views/testMiniOpamps  Viewpoint: eldonet
.INCLUDE $AnalogIP/default.group/logic.views/testMiniOpamps/eldonet/testMiniOpamps_eldonet.spi
.INCLUDE $MGC_DESIGN_KIT/models/ELDO/include_all
.PROBE VX

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27

.AC dec 10 1 1gig
