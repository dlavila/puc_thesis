* Component: $AnalogIP/default.group/logic.views/test_cmos_switch  Viewpoint: eldonet
.INCLUDE $AnalogIP/default.group/logic.views/test_cmos_switch/eldonet/test_cmos_switch_eldonet.spi
.INCLUDE $MGC_DESIGN_KIT/models/ELDO/include_all
.PROBE VX
.PROBE I
.PROBE ISUB

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27

.OPTION PROBOP2
.OPTION PROBOPX
.OP
.DC V1 0 1.8 0.01
