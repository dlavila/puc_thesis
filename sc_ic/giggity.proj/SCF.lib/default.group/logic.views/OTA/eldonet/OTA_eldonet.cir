* Component: $SCF/default.group/logic.views/OTA  Viewpoint: eldonet
.INCLUDE $SCF/default.group/logic.views/OTA/eldonet/OTA_eldonet.spi
.INCLUDE $MGC_DESIGN_KIT/models/ELDO/include_all

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27
