* Component: $SCF/default.group/logic.views/test  Viewpoint: eldonet
.INCLUDE $SCF/default.group/logic.views/test/eldonet/test_eldonet.spi
.INCLUDE $MGC_DESIGN_KIT/models/ELDO/include_all

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27

.OPTION PROBOP2
.OPTION PROBOPX
.OP
