* Component: $SC_filter/default.group/logic.views/PHASE_GEN  Viewpoint: eldonet
.INCLUDE $SC_filter/default.group/logic.views/PHASE_GEN/eldonet/CLK_gen_eldonet.spi

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27
