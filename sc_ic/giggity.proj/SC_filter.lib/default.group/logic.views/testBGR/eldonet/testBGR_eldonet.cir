* Component: $SC_filter/default.group/logic.views/testBGR  Viewpoint: eldonet
.INCLUDE $SC_filter/default.group/logic.views/testBGR/eldonet/testBGR_eldonet.spi
.INCLUDE $MGC_DESIGN_KIT/models/ELDO/include_all
.PROBE VX
.PROBE I
.PROBE ISUB

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27
.STEP  TEMP 20 60 LIN 6

.OPTION PROBOP2
.OPTION PROBOPX
.OP
.DC V1 0 1.8 1m
