* Component: $SC_filter/default.group/logic.views/SCF_ota  Viewpoint: eldonet
.INCLUDE $SC_filter/default.group/logic.views/SCF_ota/eldonet/SCF_ota_eldonet.spi

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27
